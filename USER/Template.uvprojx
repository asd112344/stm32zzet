# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\HARDWARE;..\HARDWARE\delay;..\HARDWARE\LED;..\HARDWARE\usart1;..\STM32F10x_FWLib\inc;..\USER;..\uCOSIII\BSP;..\uCOSIII\Ports;..\uCOSIII\Source;..\uCOSIII\uC-CONFIG;..\uCOSIII\uC-CPU;..\uCOSIII\uC-LIB;..\HARDWARE\dht11;..\HARDWARE\DS1302
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/delay/: delay.c
    ../HARDWARE/usart1/: usart1.c
    ./: oled.c sys.c
    ../HARDWARE/dht11/: dht11.c
    ../HARDWARE/DS1302/: ds1302.c
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_wwdg.c
  group UCOSIII_BSP
    ../uCOSIII/BSP/: bsp.c
  group UCOSIII_CPU
    ../uCOSIII/uC-CPU/: cpu_c.c cpu_core.c cpu_a.asm
  group UCOSIII_LIB
    ../uCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c lib_mem_a.asm
  group UCOSIII_CORE
    ../uCOSIII/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ../uCOSIII/Ports/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group UCOSIII_CONFIG
    ../uCOSIII/uC-CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
